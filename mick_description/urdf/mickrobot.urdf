Commit message: add ROS2 chassis node

File: mick_description/urdf/mickrobot.urdf (robot description, URDF)
Before this commit: robot mickrobot, 6 links, 5 joints
Joints:
- joint camera_joint: origin xyz=0.1 0.0 0.025 -> xyz=0.1 0.0   0.025
